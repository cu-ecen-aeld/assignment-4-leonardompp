## base_external/Config.in
```kconfig
menu "Project base packages"
    source "../base_external/package/aesd-assignments/Config.in"
endmenu
```
